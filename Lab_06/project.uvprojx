# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: main.c startup_stm32l476xx.s stm32l476xx.h README.md SysClock.c
    ../Lab_05/: I2C.c I2C_gpio.c ssd1306.c ssd1306_fonts.c ssd1306_tests.c I2C.h I2C_gpio.h ssd1306.h ssd1306_conf.h ssd1306_fonts.h ssd1306_tests.h
software components: CMSIS:CORE 5.4.0
